# Keil uVision project 双创智能小车.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 双创智能小车 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F103FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\User_file;..\USER;..\User_file\LED;..\User_file\magic;..\User_file\openmv_data;..\User_file\USART2;..\User_file\TIM_INIT;..\User_file\key;..\User_file\encoder_int;..\User_file\motor;..\User_file\Find_Track;..\User_file\oled
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../STM32F103FWLib/inc/: stm32f10x_gpio.h stm32f10x_tim.h
  group User_file
    ../User_file/LED/: LED.c
    ../User_file/magic/: magec.c
    ../User_file/openmv_data/: openmv_data.c
    ../User_file/USART2/: USART2.c
    ../User_file/TIM_INIT/: timme.c
    ../User_file/key/: key.c
    ../User_file/encoder_int/: encoder.c
    ../User_file/motor/: motor.c
    ../User_file/Find_Track/: find_track.c
    ../User_file/oled/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group STM32F103FWLib
    ../STM32F103FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
